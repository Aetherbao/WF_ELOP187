# Keil uVision project TLE9879QXW40_BLDC.uvprojx, settings and files
target Source (6190000::V6.19::ARMCLANG)
  device: TLE9879QXW40 Infineon
  pack: Infineon.TLE987x_DFP.1.6.0
  cpu: IRAM(0x18000018,0x17E8) IRAM2(0x18000000,0x14) IROM(0x11000000,0x1EFFC) IROM2(0x1101EFFC,0x1004) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GEELY_APP +hex
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=1
  c include: .\Source\BSW\BSW_ComDrv;.\Source\BSW\BSW_ADC;.\Source\BSW\BSW_BDRV;.\Source\BSW\BSW_DIAG;.\Source\BSW\BSW_DIO;.\Source\BSW\BSW_Mem;.\Source\BSW\BSW_PosSCD;.\Source\BSW\BSW_PWM;.\Source\BSW\BSW_SPI;.\Source\BSW\BSW_Sys;.\Source\BSW\BSW_Task;.\Source\BSW\BSW_DevDrv\_Source;.\Source\BSW\BSW_DevDrv\Device\TLE9879QXW40;.\Source\BSW\BSW_DevDrv\HSI_SW;.\Source\BSW\BSW_DevDrv\cmsis;.\Source\BSW\BSW_ComIf;.\Source\BSW\BSW_ProtStk\Communicaton\LinIf_Cbk;.\Source\BSW\BSW_ProtStk\Communicaton\LinIf_Cfg;.\Source\BSW\BSW_ProtStk\Communicaton\LinSlave;.\Source\BSW\BSW_ProtStk\Diagnostic\LinTp;.\Source\BSW\BSW_ProtStk\Diagnostic\Uds;.\Source\BSW\BSW_ProtStk\Integration;.\Source\BSW\BSW_ProtStk\Utils;.\Source\BSW\BSW_ProtStk\Hal;.\Source\BSW\BSW_ProtStk\Mcal;.\Source\MID;.\Source\ASW\ASW_AST;.\Source\ASW\ASW_DcycGen;.\Source\ASW\ASW_OBD;.\Source\ASW\ASW_par;.\Source\ASW\ASW_PhCurrGen;.\Source\ASW\ASW_PhVltgGen;.\Source\ASW\ASW_share;.\Source\ASW\ASW_SigIn
  library: MicroLIB
  memory RVCT4: ROM 0x11000000 size 0x1effc
  memory RVCT5: ROM 0x1101effc size 0x1004
  memory RVCT9: RAM 0x18000018 size 0x5e8
  memory RVCT10: RAM 0x18000600 size 0xd0
  scatter file: .\Objects\TLE9878_BDRV.sct
  group BSW_ADC
    ./Source/BSW/BSW_ADC/: ADC_Meas.c
  group BSW_BDRV
    ./Source/BSW/BSW_BDRV/: BDRV_BDRV.c
  group BSW_DIAG
    ./Source/BSW/BSW_DIAG/: DIAG_Handle.c
  group BSW_DIO
    ./Source/BSW/BSW_DIO/: DIO_Dio.c
  group BSW_Mem
    ./Source/BSW/BSW_Mem/: Mem_Mem.c
  group BSW_PosSCD
    ./Source/BSW/BSW_PosSCD/: PosSCD_PosSensor.c
  group BSW_PWM
    ./Source/BSW/BSW_PWM/: PWM_Clac.c PWM_Pwm.c
  group BSW_SPI
    ./Source/BSW/BSW_SPI/: SPI_SSC.c
  group BSW_Sys
    ./Source/BSW/BSW_Sys/: Sys_DMA.c Sys_Int.c Sys_SCU.c Sys_Timer2x.c Sys_McuInit.c
    ./Source/BSW/: Main.c
  group BSW_Task
    ./Source/BSW/BSW_Task/: Task_Task.c
  group BSW_DevDrv
    ./Source/BSW/BSW_DevDrv/HSI_SW/: HSI_SW.c
    ./Source/BSW/BSW_DevDrv/Device/TLE9879QXW40/: adc1.c adc2.c bdrv.c bootrom.c ccu6.c csa.c dma.c gpt12e.c int.c isr.c lin.c mon.c pmu.c port.c scu.c ssc.c system_tle987x.c timer2x.c tle_device.c uart.c wdt1.c startup_tle987x.S timer3.c
  group BSW_ComDrv
    ./Source/BSW/BSW_ComDrv/: genLinConfig.c lin_driver_api.c lin_hal.c lin_main.c lin_slave_task.c linmain.c Lintask.c
  group BSW_ComIf
    ./Source/BSW/BSW_ComIf/: ComIf_application_message.c ComIf_ECUReset_HAL.c ComIf_Init.c ComIf_RdDaByID_HAL.c ComIf_SA_HAL.c ComIf_Task.c ComIf_WrDaByID_HAL.c
  group BSW_ProtStk
    ./Source/BSW/BSW_ProtStk/Communicaton/LinIf_Cbk/: LinIf_GotoSleepConfirmation.c LinIf_GotoSleepIndication.c LinIf_HeaderIndication.c LinIf_RxIndication.c LinIf_TxConfirmation.c LinIf_WakeupConfirmation.c
    ./Source/BSW/BSW_ProtStk/Communicaton/LinIf_Cfg/: LinIf_Cfg.c
    ./Source/BSW/BSW_ProtStk/Communicaton/LinSlave/: LinSlave_MainFunction.c LinSlave_Proc.c
    ./Source/BSW/BSW_ProtStk/Diagnostic/LinTp/: LinTp.c LinTp_Cbk.c LinTp_export.c LinTp_Queue.c LinTp_SchM.c LinTp_Timer.c
    ./Source/BSW/BSW_ProtStk/Diagnostic/Uds/: uds.c uds_cfg.c uds_user.c
    ./Source/BSW/BSW_ProtStk/Integration/: fbl_infor.c
    ./Source/BSW/BSW_ProtStk/Utils/: utils.c
  group MID_Interface
    ./Source/MID/: MID_Interface.c
  group ASW_DcycGen
    ./Source/ASW/ASW_DcycGen/: ASW_DcycGen.c
  group ASW_PhVltgGen
    ./Source/ASW/ASW_PhVltgGen/: ASW_PhVltgGen.c
  group ASW_PhCurrGen
    ./Source/ASW/ASW_PhCurrGen/: ASW_PhCurrGen.c
  group ASW_AST
    ./Source/ASW/ASW_AST/: ASW_AST.c
  group ASW_OBD
    ./Source/ASW/ASW_OBD/: ASW_OBD.c
  group ASW_SigIn
    ./Source/ASW/ASW_SigIn/: ASW_SigIn.c
  group ASW_share
    ./Source/ASW/ASW_share/: const_params.c div_nde_s32_floor.c div_nzp_repeat_u32.c look1_is16lu32n32ys16n_2jZdipat.c look1_is16lu32n32ys16n_eAC3J1UD.c look1_iu8lu32n16ts16Ds32_binlcs.c look1_iu16lu32n16ts16D_2s4GBl96.c look1_iu16lu32n16tu8_binlcse.c look2_is16lu32n16tu16_binlcse.c mul_s32_hiSR.c mul_s32_loSR.c mul_ssu32_hiSR.c mul_ssu32_loSR.c mul_ssu32_sr32.c mul_wide_s32.c mul_wide_su32.c look2_iu8s16lu32n16tu16_binlcse.c
  group ASW_par
    ./Source/ASW/ASW_par/: motor_control_param.c motor_param.c
